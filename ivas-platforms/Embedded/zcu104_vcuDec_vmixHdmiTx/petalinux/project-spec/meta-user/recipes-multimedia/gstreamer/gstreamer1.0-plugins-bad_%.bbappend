
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-kmssink-Send-video-alignment-info-in-pool-config.patch \
"
