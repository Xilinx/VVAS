FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-Populating-video-alignment-info-in-GstVideometa-of-k.patch"
