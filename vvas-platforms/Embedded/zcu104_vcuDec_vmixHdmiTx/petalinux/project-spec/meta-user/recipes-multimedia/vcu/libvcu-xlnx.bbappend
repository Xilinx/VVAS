FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-fix-dec-check-vui-timing-info-present-before-using-t.patch \
"
