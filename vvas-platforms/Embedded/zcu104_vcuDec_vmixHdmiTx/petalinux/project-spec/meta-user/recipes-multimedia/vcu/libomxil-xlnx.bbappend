FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-fix-2022.2-Store-initial-GST-display-resolution.patch"
